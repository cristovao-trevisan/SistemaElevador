# IAR project Backup of cmsis_rtx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\Include; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Utilities\STM32F4-Discovery; Libraries\CMSIS\RTX\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: cmsis_rtx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS-RTX/Configuration
    Libraries/CMSIS/RTX/Templates/: RTX_Conf_CM.c
  group CMSIS-RTX/Library
    Libraries/CMSIS/RTX/lib/IAR/: RTX_CM4.a
  group EWARM
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4Discovery
    Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c usart.c
